# Keil uVision project GD32307C_EVAL.uvprojx, settings and files
target GD32F307C_EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F307VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32307C_EVAL +hex
  AfterMake: fromelf --bin --output .\output\GD32307C_EVAL.bin .\output\GD32307C_EVAL.axf
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_CL,__FPU_PRESENT
  c include: ..\..\..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_standard_peripheral\Include;..\..\..\..\..\Utilities;..\inc;..\..\..\Third_party\lwip-1.4.1\src\include;..\..\..\Third_party\lwip-1.4.1\src\include\ipv4;..\..\..\Third_party\lwip-1.4.1\src\include\netif;..\..\..\Third_party\lwip-1.4.1\src\include\lwip;..\..\..\Third_party\lwip-1.4.1\port\GD32F30x;..\..\..\Third_party\lwip-1.4.1\port\GD32F30x\FreeRTOS;..\..\..\Third_party\lwip-1.4.1\port\GD32F30x\arch;..\..\..\Third_party\FreeRTOS-8.2.3\include;..\..\..\Third_party\FreeRTOS-8.2.3\portable\RVDS\ARM_CM3;C:\Users\12421\AppData\Local\Arm\Packs\ARM\CMSIS\5.7.0\CMSIS\Include;..\..\..\..\..\Utilities\LCD_Commom;..\src;..\..\..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_standard_peripheral\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x1f000
  memory RVCT5: ROM 0x8021000 size 0x1f000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../src/: main.c tcp_client.c udp_echo.c gd32f30x_enet_eval.c gd32f30x_it.c protocol_usart.c protocol_modbus.c protocol_i2c.c module_display.c module_led.c module_audio.c module_key.c module_gd25qxx.c module_adc.c module_rtc.c app_telnet.c app_service_console.c app_netconf.c app_ota.c app_mqtt.c app_rs485net.c app_configure.c app_format.c tcp_server.c
    ../src/MQTT/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c transport.c
  group CMSIS
    ../src/: system_gd32f30x.c
  group GD32F30x_Peripherals
    ../../../../../../GD32F30x_Firmware_Library/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group GD32F30x_EVAL
    ../../../../../Utilities/: gd32f307c_eval.c
  group Startup
    ../../../../../../GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_cl.s
  group Lwip
    ../../../Third_party/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c lwip_timers.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../../../Third_party/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../Third_party/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../Third_party/lwip-1.4.1/src/netif/: etharp.c
  group Lwip_port
    ../../../Third_party/lwip-1.4.1/port/GD32F30x/FreeRTOS/: ethernetif.c sys_arch.c
  group FreeRTOS
    ../../../Third_party/FreeRTOS-8.2.3/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../Third_party/FreeRTOS-8.2.3/portable/MemMang/: heap_2.c
    ../../../Third_party/FreeRTOS-8.2.3/portable/RVDS/ARM_CM3/: port.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.4.0
