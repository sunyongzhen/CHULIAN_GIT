# Keil uVision project GD32307C_EVAL.uvprojx, settings and files
target GD32F307C_EVAL (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F307VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32307C_EVAL +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_CL,__FPU_PRESENT
  c include: ..\..\..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_standard_peripheral\Include;..\..\..\..\..\Utilities;..\inc;..\..\..\Third_party\lwip-1.4.1\src\include;..\..\..\Third_party\lwip-1.4.1\src\include\ipv4;..\..\..\Third_party\lwip-1.4.1\src\include\netif;..\..\..\Third_party\lwip-1.4.1\src\include\lwip;..\..\..\Third_party\lwip-1.4.1\port\GD32F30x;..\..\..\Third_party\lwip-1.4.1\port\GD32F30x\Basic
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../src/: main.c netconf.c hello_gigadevice.c tcp_client.c udp_echo.c gd32f30x_enet_eval.c gd32f30x_it.c
  group CMSIS
    ../src/: system_gd32f30x.c
  group GD32F30x_Peripherals
    ../../../../../../GD32F30x_Firmware_Library/GD32F30x_standard_peripheral/Source/: gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exti.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_usart.c gd32f30x_wwdgt.c gd32f30x_rcu.c
  group GD32F30x_EVAL
    ../../../../../Utilities/: gd32f307c_eval.c
  group Startup
    ../../../../../../GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_cl.s
  group Lwip
    ../../../Third_party/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c lwip_timers.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../../../Third_party/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../Third_party/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../Third_party/lwip-1.4.1/src/netif/: etharp.c
  group Lwip_port
    ../../../Third_party/lwip-1.4.1/port/GD32F30x/Basic/: ethernetif.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.4.0
