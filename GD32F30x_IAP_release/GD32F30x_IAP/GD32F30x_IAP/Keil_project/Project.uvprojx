# Keil uVision project Project.uvprojx, settings and files
target GD32F30X_CL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F307ZG GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_CL,PRINTF
  c include: ..\..\GD32F30x_Firmware_Library_V2.0.0\GD32F30x_Firmware_Library\Firmware\CMSIS;..\..\GD32F30x_Firmware_Library_V2.0.0\GD32F30x_Firmware_Library\Firmware\CMSIS\GD\GD32F30x\Include;..\..\GD32F30x_Firmware_Library_V2.0.0\GD32F30x_Firmware_Library\Firmware\GD32F30x_standard_peripheral\Include;..\..\GD32F30x_Firmware_Library_V2.0.0\GD32F30x_Firmware_Library\Utilities;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../: gd32f30x_it.c main.c
  group CMSIS
    ../../GD32F30x_Firmware_Library_V2.0.0/GD32F30x_Firmware_Library/Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Peripherals
    ../../GD32F30x_Firmware_Library_V2.0.0/GD32F30x_Firmware_Library/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_dma.c gd32f30x_fmc.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_rcu.c
  group Startup
    ../../GD32F30x_Firmware_Library_V2.0.0/GD32F30x_Firmware_Library/Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_cl.s startup_gd32f30x_hd.s startup_gd32f30x_xd.s
  group Doc
    ../: readme.txt
target GD32F30X_XD (ARM-ADS)
  device: GD32F303RK GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_XD,PRINTF
  c include: ..\..\GD32F30x_Firmware_Library_V2.0.0\GD32F30x_Firmware_Library\Firmware\CMSIS;..\..\GD32F30x_Firmware_Library_V2.0.0\GD32F30x_Firmware_Library\Firmware\CMSIS\GD\GD32F30x\Include;..\..\GD32F30x_Firmware_Library_V2.0.0\GD32F30x_Firmware_Library\Firmware\GD32F30x_standard_peripheral\Include;..\..\GD32F30x_Firmware_Library_V2.0.0\GD32F30x_Firmware_Library\Utilities;..\..\GD32F30x_Firmware_Library_V2.0.0\GD32F30x_Firmware_Library\Template;..\..\GD32F30x_Firmware_Library_V2.0.0\GD32F30x_Firmware_Library\Firmware\CMSIS\GD\GD32F30x\Source\ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x18000
target GD32F30X_HD (ARM-ADS)
  device: GD32F307VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD,PRINTF
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
software components: CMSIS:CORE 5.1.1
